<?xml version="1.0"?>
<setupdb version="8">history
	<active>Active Setup</active>
	<history>History</history>
</setupdb>
